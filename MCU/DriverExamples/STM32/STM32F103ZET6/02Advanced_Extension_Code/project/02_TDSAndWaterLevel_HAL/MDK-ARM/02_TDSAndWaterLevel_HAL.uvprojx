# Keil uVision project 02_TDSAndWaterLevel_HAL.uvprojx, settings and files
target 02_TDSAndWaterLevel_HAL (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: 02_TDSAndWaterLevel_HAL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Driver\fsmc;..\Driver\gpio;..\Driver\spi;..\Driver\usart;..\Inf\ads1115;..\Inf\lcd;..\Inf\TM7711;..\Inf\w25q32;..\app\display;..\app\tds;..\app\wl;..\common\debug
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c fsmc.c i2c.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_ll_fsmc.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_sram.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Driver
    ../Driver/fsmc/: Driver_FSMC.c
    ../Driver/gpio/: Driver_GPIO.c
    ../Driver/spi/: Driver_SPI.c
    ../Driver/usart/: Driver_USART.c
  group Inf
    ../Inf/ads1115/: Inf_Ads1115.c
    ../Inf/lcd/: Inf_LCD.c
    ../Inf/TM7711/: Inf_TM7711.c
    ../Inf/w25q32/: Inf_W25Q32.c
  group App
    ../app/display/: App_Display.c
    ../app/tds/: App_TDS.c
    ../app/wl/: App_WL.c
  group Common
    ../common/debug/: Common_Debug.c
software components: CMSIS:CORE 4.3.0
