# Keil uVision project 01_TDSAndWaterLevel_Register.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 01_LED_Register +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Start;.\User;.\Driver\usart;.\common\debug;.\Driver\fsmc;.\Inf\lcd;.\app\display;.\Driver\i2c;.\Inf\ads1115;.\app\tds;.\Driver\gpio;.\Inf\TM7711;.\app\wl;.\Driver\spi;.\Inf\w25q32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group User
    ./User/: main.c Delay.c
  group Driver
    ./Driver/usart/: Driver_USART.c
    ./Driver/fsmc/: Driver_FSMC.c
    ./Driver/i2c/: Driver_I2C2.c
    ./Driver/gpio/: Driver_GPIO.c
    ./Driver/spi/: Driver_SPI.c
  group Inf
    ./Inf/lcd/: Inf_LCD.c
    ./Inf/ads1115/: Inf_Ads1115.c
    ./Inf/TM7711/: Inf_TM7711.c
    ./Inf/w25q32/: Inf_W25Q32.c
  group App
    ./app/display/: App_Display.c
    ./app/tds/: App_TDS.c
    ./app/wl/: App_WL.c
  group Common
    ./common/debug/: Common_Debug.c
