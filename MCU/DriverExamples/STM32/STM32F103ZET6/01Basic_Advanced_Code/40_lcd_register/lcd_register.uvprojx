# Keil uVision project lcd_register.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\arm5_compiler)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: led_register +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Start;.\User;.\Hardware\LED;.\Hardware\KEY;.\Hardware\USART;.\Hardware\I2C;.\Interface\EEPROM;.\Hardware\SPI;.\Interface\Flash;.\Hardware\FSMC;.\Interface\LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group User
    ./User/: main.c delay.c
  group Hardware/LED
    ./Hardware/LED/: led.c
  group Hardware/KEY
    ./Hardware/KEY/: key.c
  group Hardware/USART
    ./Hardware/USART/: usart.c
  group Hardware/I2C
    ./Hardware/I2C/: i2c.c
  group Interface/EEPROM
    ./Interface/EEPROM/: m24c02.c
  group Hardware/SPI
    ./Hardware/SPI/: spi.c
  group Interface/Flash
    ./Interface/Flash/: w25q32.c
  group Hardware/FSMC
    ./Hardware/FSMC/: fsmc.c
  group Interface/LCD
    ./Interface/LCD/: lcd.c
